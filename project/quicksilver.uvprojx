# Keil uVision project quicksilver.uvprojx, settings and files
target quicksilver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F103KBU MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.8
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quicksilver +hex
  AfterMake: fromelf --bin !L -o .\BIN\Bootloader_F103.bin
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,F103_N_VERSION,ARM_MATH_CM3
  c misc: --diag_suppress=111,177,188,1565,68,110,112
  c include: ..\lib\MM32F103\HAL_lib\inc;..\lib\MM32F103\Include;..\src\config;..\src\drivers;..\src\flight;..\src\rx;..\src\system;..\src\util;..\src\vcp;..\lib\cbor\include;..\src\sensor
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: main.c
  group config
    ../src/config/: targets.h config.h defines.h
  group drivers
    ../src/drivers/: time.c misc_gpio.c flash.c flash_io.c adc.c dshot.c rgb.c vbat.c spi.c
  group sensor
    ../src/sensor/: mpu6000.c
  group flight
    ../src/flight/: control.c filter.c imu.c angle_pid.c pid.c input.c motor.c
  group rx
    ../src/rx/: rx.c rx_spi.c rx_spi_frskyd.c cc2500.c
  group system
    ../src/system/: system_MM32F103.c startup_MM32F103.s
  group util
    ../src/util/: util.c cbor_helper.c circular_buffer.c vector.c
  group lib
    ../lib/MM32F103/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group cbor
    ../lib/cbor/src/: cbor.c
software components: CMSIS:CORE 5.4.0
